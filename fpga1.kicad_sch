File: fpga1.kicad_sch (KiCad schematic)
At the start: 1 part, among them P1 5CEFA7F23

Commit message: update schematic to v1.5
Parts:
- P1: value 5CEFA7F23 -> 5CEFA5F23
