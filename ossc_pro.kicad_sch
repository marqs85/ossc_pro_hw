File: ossc_pro.kicad_sch (KiCad schematic)
At the start: 9 parts

Commit message: update schematic to v1.5
Parts:
- MH1, MH2, MH3, MH4, MH5, MH6, MH7: now left out of the parts list
